<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>helloworld</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>bb_gain</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>20</value></param>
<param><key>label</key><value></value></param>
<param><key>max</key><value>30</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>freq</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>105.2e6</value></param>
<param><key>label</key><value></value></param>
<param><key>max</key><value>108e6</value></param>
<param><key>min</key><value>88e6</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>if_gain</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>20</value></param>
<param><key>label</key><value></value></param>
<param><key>max</key><value>30</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>rf_gain</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>20</value></param>
<param><key>label</key><value></value></param>
<param><key>max</key><value>30</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>sample_rate</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>2.048e6</value></param>
<param><key>label</key><value></value></param>
<param><key>max</key><value>3.2e6</value></param>
<param><key>min</key><value>1.6e6</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>analog_wfm_rcv</key>
<param><key>id</key><value>analog_wfm_rcv_0</value></param>
<param><key>audio_decimation</key><value>int(sample_rate/24000)</value></param>
<param><key>quad_rate</key><value>freq</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>24000</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0</value></param>
<param><key>bb_gain0</key><value>bb_gain</value></param>
<param><key>freq0</key><value>freq</value></param>
<param><key>gain_mode0</key><value>True</value></param>
<param><key>if_gain0</key><value>if_gain</value></param>
<param><key>iq_balance_mode0</key><value>2</value></param>
<param><key>gain0</key><value>rf_gain</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>sample_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxs</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>baseband_freq</key><value>freq</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>samp_rate</key><value>sample_rate</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>None</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>y_per_div</key><value>10</value></param>
</block>
<connection><source_block_id>analog_wfm_rcv_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>analog_wfm_rcv_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>wxs</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
